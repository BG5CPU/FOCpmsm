# Keil uVision project SPI3_Test_a.uvprojx, settings and files
target SPI3_Test_a (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: SPI3_Test_a +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ../Inc;                                              ../Drivers/STM32F7xx_HAL_Driver/Inc;                                              ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                                              ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                                              ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: gpio.c stm32f7xx_hal_msp.c spi.c main.c stm32f7xx_it.c sintable.c Controller.c tim.c adc.c dma.c fmc.c pid.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_flash.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_rcc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_sram.c stm32f7xx_ll_fmc.c
software components: CMSIS:CORE 4.1.0
